#include <SPI.h>
#include "Display_EPD_W21_spi.h"
#include "Display_EPD_W21.h"
#include "Ap_29demo.h"
#define TEXT_MAX_LEN 64

// Minimal 8x16 ASCII font (space + A-Z + 0-9)
const unsigned char Font8x16[][16] = {
  {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // Space
  {0x00,0x18,0x18,0x3C,0x24,0x24,0x42,0x42,0x7E,0x42,0x42,0x42,0x42,0x00,0x00,0x00}, // A
  {0x00,0x7C,0x42,0x42,0x7C,0x42,0x42,0x42,0x42,0x7C,0x00,0x00,0x00,0x00,0x00,0x00}, // B
  {0x00,0x3C,0x42,0x40,0x40,0x40,0x40,0x40,0x42,0x3C,0x00,0x00,0x00,0x00,0x00,0x00}, // C
  {0x00,0x78,0x44,0x42,0x42,0x42,0x42,0x42,0x44,0x78,0x00,0x00,0x00,0x00,0x00,0x00}, // D
  {0x00,0x7E,0x40,0x40,0x7C,0x40,0x40,0x40,0x40,0x7E,0x00,0x00,0x00,0x00,0x00,0x00}, // E
  {0x00,0x7E,0x40,0x40,0x7C,0x40,0x40,0x40,0x40,0x40,0x00,0x00,0x00,0x00,0x00,0x00}, // F
  {0x00,0x3C,0x42,0x40,0x40,0x4E,0x42,0x42,0x42,0x3C,0x00,0x00,0x00,0x00,0x00,0x00}, // G
  {0x00,0x42,0x42,0x42,0x7E,0x42,0x42,0x42,0x42,0x42,0x00,0x00,0x00,0x00,0x00,0x00}, // H
  {0x00,0x3C,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x3C,0x00,0x00,0x00,0x00,0x00,0x00}, // I
  {0x00,0x0E,0x04,0x04,0x04,0x04,0x04,0x44,0x44,0x38,0x00,0x00,0x00,0x00,0x00,0x00}, // J
  {0x00,0x42,0x44,0x48,0x70,0x48,0x44,0x42,0x42,0x42,0x00,0x00,0x00,0x00,0x00,0x00}, // K
  {0x00,0x40,0x40,0x40,0x40,0x40,0x40,0x40,0x40,0x7E,0x00,0x00,0x00,0x00,0x00,0x00}, // L
  {0x00,0x42,0x66,0x5A,0x5A,0x42,0x42,0x42,0x42,0x42,0x00,0x00,0x00,0x00,0x00,0x00}, // M
  {0x00,0x42,0x62,0x52,0x4A,0x46,0x42,0x42,0x42,0x42,0x00,0x00,0x00,0x00,0x00,0x00}, // N
  {0x00,0x3C,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x3C,0x00,0x00,0x00,0x00,0x00,0x00}, // O
  {0x00,0x7C,0x42,0x42,0x42,0x7C,0x40,0x40,0x40,0x40,0x00,0x00,0x00,0x00,0x00,0x00}, // P
  {0x00,0x3C,0x42,0x42,0x42,0x42,0x42,0x4A,0x44,0x3A,0x00,0x00,0x00,0x00,0x00,0x00}, // Q
  {0x00,0x7C,0x42,0x42,0x42,0x7C,0x48,0x44,0x42,0x42,0x00,0x00,0x00,0x00,0x00,0x00}, // R
  {0x00,0x3C,0x42,0x40,0x3C,0x02,0x02,0x42,0x42,0x3C,0x00,0x00,0x00,0x00,0x00,0x00}, // S
  {0x00,0x7E,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x00,0x00,0x00,0x00,0x00,0x00}, // T
  {0x00,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x3C,0x00,0x00,0x00,0x00,0x00,0x00}, // U
  {0x00,0x42,0x42,0x42,0x42,0x42,0x42,0x24,0x24,0x18,0x00,0x00,0x00,0x00,0x00,0x00}, // V
  {0x00,0x42,0x42,0x42,0x42,0x5A,0x5A,0x24,0x24,0x24,0x00,0x00,0x00,0x00,0x00,0x00}, // W
  {0x00,0x42,0x24,0x24,0x18,0x18,0x18,0x24,0x24,0x42,0x00,0x00,0x00,0x00,0x00,0x00}, // X
  {0x00,0x42,0x42,0x24,0x24,0x18,0x18,0x18,0x18,0x18,0x00,0x00,0x00,0x00,0x00,0x00}, // Y
  {0x00,0x7E,0x02,0x04,0x08,0x10,0x20,0x40,0x40,0x7E,0x00,0x00,0x00,0x00,0x00,0x00}, // Z
  {0x00,0x3C,0x42,0x46,0x4A,0x52,0x62,0x42,0x42,0x3C,0x00,0x00,0x00,0x00,0x00,0x00}, // 0
  {0x00,0x08,0x18,0x28,0x08,0x08,0x08,0x08,0x08,0x3E,0x00,0x00,0x00,0x00,0x00,0x00}, // 1
  {0x00,0x3C,0x42,0x02,0x04,0x08,0x10,0x20,0x42,0x7E,0x00,0x00,0x00,0x00,0x00,0x00}, // 2
  {0x00,0x3C,0x42,0x02,0x1C,0x02,0x02,0x42,0x42,0x3C,0x00,0x00,0x00,0x00,0x00,0x00}, // 3
  {0x00,0x04,0x0C,0x14,0x24,0x44,0x7E,0x04,0x04,0x04,0x00,0x00,0x00,0x00,0x00,0x00}, // 4
  {0x00,0x7E,0x40,0x40,0x7C,0x02,0x02,0x42,0x42,0x3C,0x00,0x00,0x00,0x00,0x00,0x00}, // 5
  {0x00,0x3C,0x42,0x40,0x40,0x7C,0x42,0x42,0x42,0x3C,0x00,0x00,0x00,0x00,0x00,0x00}, // 6
  {0x00,0x7E,0x42,0x04,0x08,0x08,0x10,0x10,0x10,0x10,0x00,0x00,0x00,0x00,0x00,0x00}, // 7
  {0x00,0x3C,0x42,0x42,0x42,0x3C,0x42,0x42,0x42,0x3C,0x00,0x00,0x00,0x00,0x00,0x00}, // 8
  {0x00,0x3C,0x42,0x42,0x42,0x3E,0x02,0x02,0x42,0x3C,0x00,0x00,0x00,0x00,0x00,0x00}  // 9
};

// Map ASCII character to font index
int getFontIndex(char c) {
  if (c == ' ') return 0;
  if (c >= 'A' && c <= 'Z') return c - 'A' + 1;
  if (c >= '0' && c <= '9') return c - '0' + 27;
  return 0; // fallback
}

void setup() {
  Serial.begin(115200);

  // E-Paper pins
  pinMode(34, INPUT);   // BUSY
  pinMode(16, OUTPUT);  // RES
  pinMode(17, OUTPUT);  // DC
  pinMode(5, OUTPUT);   // CS

  SPI.begin(18, -1, 23, -1); // HSPI
  SPI.beginTransaction(SPISettings(10000000, MSBFIRST, SPI_MODE0));

  EPD_HW_Init();
  EPD_W21_WriteCMD(0x11); // data entry mode
  EPD_W21_WriteDATA(0x01);
  EPD_WhiteScreen_White();
  delay(500);
  EPD_HW_Init(); //Full screen refresh initialization.
  EPD_WhiteScreen_ALL(valve_image_close); //To Display one image using full screen refresh.
  EPD_DeepSleep(); //Enter the sleep mode and please do not delete it, otherwise it will reduce the lifespan of the screen.
  delay(2000); //Delay for 2s. 
}

void loop() {
  if (Serial.available()) {
    String text = Serial.readStringUntil('\n');
    text.toUpperCase();
   // text = reverseString(text); // reverse to fix mirror issue
    displayTextVertical(text);
    Serial.println("Printed: " + text);
  }
  delay(100);
}

// Reverse string
String reverseString(String s) {
  String r = "";
  for (int i = s.length() - 1; i >= 0; i--) r += s[i];
  return r;
}

// Display vertical text
void displayTextVertical(String text) {
  unsigned char buffer[EPD_ARRAY];
  for (int i = 0; i < EPD_ARRAY; i++) buffer[i] = 0xFF;

  int x = 0;
  int y = 0;
  for (int i = 0; i < text.length() && i < TEXT_MAX_LEN; i++) {
    char c = text[i];
    drawCharToBufferVertical(buffer, x, y, c);
    y += 8;
    if (y + 8 > EPD_HEIGHT) {
      y = 0;
      x += 16;
      if (x + 16 > EPD_WIDTH) break;
    }
  }

  EPD_WhiteScreen_ALL(buffer);
  delay(2000);
}

// Draw character vertically
void drawCharToBufferVertical(unsigned char *buffer, int x, int y, char c) {
  int fontIndex = getFontIndex(c);
  const unsigned char *charData = Font8x16[fontIndex];

  for (int row = 0; row < 16; row++) {
    unsigned char line = charData[row];
    for (int col = 0; col < 8; col++) {
      int pixel = (line >> (7 - col)) & 0x01;
      int px = x + row;  // horizontal moves with row
      int py = y + col;  // vertical moves with col
      if (px >= EPD_WIDTH || py >= EPD_HEIGHT) continue;
      int index = px / 8 + py * (EPD_WIDTH / 8);
      if (pixel)
        buffer[index] &= ~(0x80 >> (px % 8));
      else
        buffer[index] |= (0x80 >> (px % 8));
    }
  }
}
